<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\proj_bootloader\Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\proj_firmware\Firmware.ewp</path>
  </project>
  <batchBuild/>
</workspace>


