# IAR project Firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; OS_FREERTOS; NMS_UPGRADE_DEBUG; USE_STDPERIPH_DRIVER; STM32F2XX; SERIES_10G; BOARDMCU=REMOTE_MCU; FPGAI2CEN; SI5327; MCUCODEID=0x34700105; VAR3S_10GOLT_V1_10; BOARD_NAME="GV3S-HONUE-QM_V1.00"; F3IMAGENAME="var3s.4.1A.002"
  ICCARM.CCDiagSuppress: pa050,pe188,pa089,pe177,pe550,pe111,pe191
  ICCARM.CCIncludePath2: ..\..\firmware; ..\..\..\..\platform\os\freertos_v6.1.0\include; ..\..\..\..\platform\os\freertos_v6.1.0\portable\EWARM\ARM_CM3; ..\..\..\..\platform\os\osif; ..\..\..\..\platform\util; ..\..\..\..\platform\hal_switch; ..\..\..\..\platform\stm32f2xx\startup; ..\..\..\..\platform\stm32f2xx\drivers; ..\..\..\..\platform\stm32f2xx\std_periph_driver; ..\..\..\..\protocol\lwip_v1.3.2\src\include; ..\..\..\..\protocol\lwip_v1.3.2\src\include\lwip; ..\..\..\..\protocol\lwip_v1.3.2\src\include\netip; ..\..\..\..\protocol\lwip_v1.3.2\src\include\ipv4; ..\..\..\..\protocol\lwip_v1.3.2\port\STM32F2x7; ..\..\..\..\protocol\lwip_v1.3.2\port\STM32F2x7\FreeRTOS; ..\..\..\..\protocol\obring; ..\..\..\..\feature\cli\rli_code\include; ..\..\..\..\feature\cli\rli_code\rcc\include; ..\..\..\..\feature\cli\rli_code\rc_gen; ..\..\..\..\feature\cli\rli_code\rcc_tut\include; ..\..\..\..\feature\cli\rli_code\custom; ..\..\..\..\feature\cm; ..\..\..\..\feature\comsrv; ..\..\..\..\feature\drvtest; ..\..\..\..\feature\nms\obpriv; ..\..\..\..\feature\nms\privmib; ..\..\..\..\feature\sigsrv; ..\..\..\..\feature\fpga\drv; ..\..\..\..\feature\fpga\si5327; ..\..\..\..\feature\fpga\misc; ..\..\..\..\feature\fpga\fpga_app; ..\..\..\..\feature\fpga\tlk10232; ..\..\..\..\feature\fpga\hal; ..\..\..\..\feature\fpga\fpga_debug; ..\..\..\..\feature\dsdt\porting; ..\..\..\..\feature\dsdt\inc; ..\..\..\..\feature\dsdt\inc\h\driver; ..\..\..\..\feature\dsdt\inc\h\msApi; ..\..\..\..\feature\dsdt\inc\h\platform
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: FreeRTOS
  AARM.AUserIncludes: ..\..\firmware
  OBJCOPY.OOCOutputFile: Firmware.bin
  prebuild: ..\..\images\pre_build.bat
  postbuild: ..\..\images\post.bat
  ILINK.IlinkOutputFile: Firmware.out
  ILINK.IlinkIcfFile: ..\..\lcf\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Apps
    ../../firmware/: main.c netconf.c run_timer.c stm32f2xx_it.c
  group Feature/CLI/cli_if
    ../../../../feature/cli/cli_if/: cli_main.c rc_freertos.c rc_sock_freertos.c
  group Feature/CLI/common
    ../../../../feature/cli/rli_code/common/: rc_access.c rc_auth.c rc_base64.c rc_binsrch.c rc_compare.c rc_convert.c rc_enum.c rc_hash.c rc_linklist.c rc_md5.c rc_msghdlr.c rc_rlstdlib.c rc_sizeof.c rc_tcpd.c rc_tree.c
  group Feature/CLI/custom
    ../../../../feature/cli/rli_code/custom/: cli_debug.c cli_obring.c cli_ping.c cli_port.c cli_signal.c cli_sys.c cli_tftp.c cli_trap.c cli_uart.c cli_util.c
  group Feature/CLI/ocb
    ../../../../feature/cli/rli_code/ocb/: rc_cache.c rc_database.c rc_environ.c rc_ocb_init.c
  group Feature/CLI/rc_gen
    ../../../../feature/cli/rli_code/rc_gen/: ansi.c rc_ignition.c rcc_cli.c rcc_handlers.c
  group Feature/CLI/rcc
    ../../../../feature/cli/rli_code/rcc/: rcc_alias.c rcc_cmd.c rcc_db.c rcc_ext.c rcc_help.c rcc_hist.c rcc_rcb.c rcc_system.c rcc_task.c rcc_telnet.c rcc_telnetd.c rcc_util.c
  group Feature/CLI/rcc_tut
    ../../../../feature/cli/rli_code/rcc_tut/: vd_basic.c vd_custom.c vd_glue_basic.c vd_glue_struct.c vd_glue_table.c
  group Feature/CLI/rli_os
    ../../../../feature/cli/rli_code/rli_os/: rc_ansifs.c rc_chorus.c rc_crc32.c rc_decomp.c rc_filemgr.c rc_inflate.c rc_memmgr.c rc_netbsd.c rc_nucleus.c rc_posix.c rc_prop_os.c rc_psos.c rc_skchorus.c rc_skt_prop.c rc_skt_psos.c rc_skt_sysv.c rc_sktnetbsd.c rc_sktposix.c rc_sock_att.c rc_sock_nu.c rc_sock_vrt.c rc_sock_vxw.c rc_sock_w32.c rc_sockif.c rc_ssl.c rc_sysv.c rc_vrtx.c rc_vxdev.c rc_vxworks.c rc_win32.c
  group Feature/CM
    ../../../../feature/cm/: conf_global.c conf_obring.c conf_port.c conf_ring.c conf_signal.c conf_sys.c conf_uart.c
  group Feature/ComSrv
    ../../../../feature/comsrv/: uart_server.c
  group Feature/DrvTest
    ../../../../feature/drvtest/: drvtest.c
  group Feature/DSDT/Porting
    ../../../../feature/dsdt/porting/: oam_port.c osSem.c switch_init.c switch_mii.c
  group Feature/DSDT/Src/Driver
    ../../../../feature/dsdt/src/driver/: gtDrvConfig.c gtDrvEvents.c gtHwCntl.c
  group Feature/DSDT/Src/Msapi
    ../../../../feature/dsdt/src/msapi/: gtBrgFdb.c gtBrgStp.c gtBrgVlan.c gtBrgVtu.c gtEvents.c gtPCSCtrl.c gtPhyCtrl.c gtPhyInt.c gtPIRL.c gtPortCtrl.c gtPortPav.c gtPortRateCtrl.c gtPortRmon.c gtPortStat.c gtPortStatus.c gtQosMap.c gtSysConfig.c gtSysCtrl.c gtSysStatus.c gtUtils.c gtVct.c gtVersion.c
  group Feature/DSDT/Src/Platform
    ../../../../feature/dsdt/src/platform/: gtDebug.c gtMiiSmiIf.c gtSem.c platformDeps.c
  group Feature/FPGA/drv
    ../../../../feature/fpga/drv/: i2c_ee.c
  group Feature/FPGA/fpga_app
    ../../../../feature/fpga/fpga_app/: common.c fpga_task.c spi_flash.c tsensor.c upgrade.c
  group Feature/FPGA/fpga_debug
    ../../../../feature/fpga/fpga_debug/: fpga_debug.c
  group Feature/FPGA/hal
    ../../../../feature/fpga/hal/: fpga_api.c hal_io.c hal_time.c hal_uart.c halcmd_msg.c halsw_i2c.c
  group Feature/FPGA/misc
    ../../../../feature/fpga/Misc/: delay.c fifo.c
  group Feature/FPGA/Si5327
    ../../../../feature/fpga/si5327/: si5327.c si5327regconf.c
  group Feature/FPGA/tlk10232
    ../../../../feature/fpga/tlk10232/: tlk10232.c
  group Feature/iwdgtask
    ../../../../feature/iwdgtask/: iwdgtask.c
  group Feature/NMS
    ../../../../feature/nms/obpriv/: nms_global.c nms_if.c nms_port.c nms_ring.c nms_sys.c nms_uart.c nms_upgrade.c
  group Feature/PrivMib
    ../../../../feature/nms/privmib/: obnet_switch_mib.c private_trap.c
  group Feature/sigsrv
    ../../../../feature/sigsrv/: sig_srv.c
  group Feature/tcpecho
    ../../../../feature/tcpecho/: tcpecho.c
  group Feature/udpecho
    ../../../../feature/udpecho/: udpecho.c
  group Platform/FreeRTOS_v6.1.0
    ../../../../platform/os/freertos_v6.1.0/: croutine.c list.c queue.c tasks.c
    ../../../../platform/os/freertos_v6.1.0/portable/MemMang/: heap_2.c
    ../../../../platform/os/freertos_v6.1.0/portable/EWARM/ARM_CM3/: port.c portasm.s
  group Platform/HalSwitch
    ../../../../platform/hal_switch/: hal_swif.c hal_swif_aggregation.c hal_swif_mac.c hal_swif_message.c hal_swif_mirror.c hal_swif_multicast.c hal_swif_port.c hal_swif_qos.c hal_swif_rate_ctrl.c hal_swif_txrx.c hal_swif_vlan.c
  group Platform/OSIF
    ../../../../platform/os/osif/: os_mutex.c
  group Platform/STM32F2xx/Drivers
    ../../../../platform/stm32f2xx/drivers/: console.c flash_if.c gpio_drv.c led_drv.c m88e6095_drv.c m88e6095_if.c misc_drv.c robo_drv.c rs_uart.c soft_i2c.c stm32f2x7_eth.c stm32f2x7_eth_bsp.c stm32f2x7_smi.c timer.c usart_if.c
  group Platform/STM32F2xx/Startup
    ../../../../platform/stm32f2xx/startup/: startup_stm32f2xx.s system_stm32f2xx.c
  group Platform/STM32F2xx/StdPeriphDriver
    ../../../../platform/stm32f2xx/std_periph_driver/: misc.c stm32f2xx_adc.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group Platform/Util
    ../../../../platform/util/: ob_image.c ssi_list.c
  group Protocal/LwIP_v1.3.2/Api
    ../../../../protocol/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Protocal/LwIP_v1.3.2/Core
    ../../../../protocol/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Protocal/LwIP_v1.3.2/Core/IPv4
    ../../../../protocol/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Protocal/LwIP_v1.3.2/Core/Snmp
    ../../../../protocol/lwip_v1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group Protocal/LwIP_v1.3.2/Netif
    ../../../../protocol/lwip_v1.3.2/src/netif/: etharp.c
    ../../../../protocol/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group Protocal/OB-Ring
    ../../../../protocol/obring/: ob_ring.c obring.c
