# IAR project Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; BOARD_GV3S_HONUE_QM_V1_00
  ICCARM.CCIncludePath2: ..\..\bootloader\stm32f2xx\startup; ..\..\bootloader\stm32f2xx\drivers; ..\..\bootloader\stm32f2xx\std_periph_driver; ..\..\bootloader\loader; ..\..\..\..\platform\util
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GE22103MA_Bootloader.bin
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: ..\..\lcf\stm32f2xx_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Bootloader
    ../../bootloader/loader/: bdinfo.c bootloader.c cli.c cmd_bdinfo.c cmd_misc.c ob_image.c stm32f2xx_it.c timer.c xmodem.c
  group STM32F2xx/Drivers
    ../../bootloader/stm32f2xx/drivers/: console.c flash_if.c led_drv.c soft_i2c.c
  group STM32F2xx/Startup
    ../../bootloader/stm32f2xx/startup/: startup_stm32f2xx.s system_stm32f2xx.c
  group STM32F2xx/StdPeriphDriver
    ../../bootloader/stm32f2xx/std_periph_driver/: misc.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_tim.c stm32f2xx_usart.c
